# Keil uVision project erdp_stm32.uvprojx, settings and files
target GD32 (6220000::V6.22::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: erdp +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=8 wLevel=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: -fexceptions
  c include: Source;Source\Kernel\Driver;Source\Kernel\Driver\CMSIS;Source\Kernel\RTOS\FreeRTOS;Source\Kernel\RTOS\FreeRTOS\inc;Source\Kernel\RTOS\FreeRTOS\port\GCC\ARM_CM4F;Source\Interface;Source\Interface\Hardware\inc;Source\Interface\RTOS;Source\HAL;Source\HAL\GPIO;Source\HAL\UART;Source\HAL\SPI;Source\HAL\EXTI;Source\OSAL;Source\Library;Source\Library\printf;Source\Library\log;Source\Adapter\log;Source\Common;Source\Board;.\Source\Kernel\Driver\STM32F4xx_StdPeriph_Driver\inc;.\Source\Kernel\Driver\CMSIS\Include;.\Source\Kernel\Driver\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Config
    ./Source/: erdp_config.h thread_config.h
  group Application
    ./Source/Application/: main.cpp
  group Library
    ./Source/Library/log/: log.c
  group HAL
    ./Source/HAL/: erdp_hal.hpp
    ./Source/HAL/GPIO/: erdp_hal_gpio.cpp erdp_hal_gpio.hpp
    ./Source/HAL/UART/: erdp_hal_uart.cpp erdp_hal_uart.hpp
    ./Source/HAL/SPI/: erdp_hal_spi.cpp erdp_hal_spi.hpp
    ./Source/HAL/EXTI/: erdp_hal_exti.cpp erdp_hal_exti.hpp
  group OSAL
    ./Source/OSAL/: erdp_osal.cpp erdp_osal.hpp erdp_heap.hpp
  group Interface
    ./Source/Interface/Hardware/src/: erdp_if_gpio.c erdp_if_spi.c erdp_if_uart.c erdp_if_exti.c
    ./Source/Interface/RTOS/: erdp_if_rtos.c
  group Driver
    ./Source/Kernel/Driver/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./Source/Kernel/Driver/: stm32f4xx_it.c
    ./Source/Kernel/Driver/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Source/Kernel/Driver/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ./Source/Kernel/: syscalls.c
  group RTOS
    ./Source/Kernel/RTOS/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Source/Kernel/RTOS/FreeRTOS/port/GCC/ARM_CM4F/: port.c
    ./Source/Kernel/RTOS/FreeRTOS/port/MemMang/: heap_4.c
    ./Source/Kernel/RTOS/FreeRTOS/: FreeRTOSConfig.h
